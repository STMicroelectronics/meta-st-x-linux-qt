# This package depends on the selected machine
PACKAGE_ARCH = "${MACHINE_ARCH}"
