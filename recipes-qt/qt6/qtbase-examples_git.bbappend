FILESEXTRAPATHS:prepend := "${THISDIR}/qtbase:"

SRC_URI += "file://0001-examples-opengl-cube-set-maximized-window.patch"