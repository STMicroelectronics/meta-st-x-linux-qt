# Add examples
PACKAGECONFIG:append = " examples"
