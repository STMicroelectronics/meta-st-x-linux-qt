# Add OSM service
PACKAGECONFIG += "geoservices_osm"
