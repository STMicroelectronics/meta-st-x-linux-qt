FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-environment-variables-to-disable-color-depth-ste.patch"

