RDEPENDS:${PN} += " \
    qtquick3d-mkspecs \
"
