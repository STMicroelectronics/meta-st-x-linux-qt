# This package depends on the selected machine, mesa or gcnano drivers
PACKAGE_ARCH = "${MACHINE_ARCH}"
