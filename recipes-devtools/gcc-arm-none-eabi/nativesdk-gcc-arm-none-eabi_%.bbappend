INSANE_SKIP:${PN} += " arch"
